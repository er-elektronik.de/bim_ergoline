Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ER-6 (EKW 25m).IFC
Time: 2022-03-17T10:30:33
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Acrylscheibe 10mm_EKW 25m
In: Default Storey
Material: Acrylglas
SolidWorks Custom Properties - Material: Acrylglas; Gewicht: 403.33; Version 1: EKW 17m; Version 2: EKW 25m; Version 3: EKW 34m

# IfcBuildingElementProxy: ER Blende BIM_Blende (Gehäuseteil 1) ER weiß
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 243.85

# IfcBuildingElementProxy: ER Scheibenhalter BIM_Scheibenhalter T10 25m weiß
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 82.21

# IfcBuildingElementProxy: Ergoline Technik BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: AX3 - AT.DS&BS,LFP1,3,2V 3h 1,2W; Version 2: AX8 - AT.DS&BS,LFP1,3,2V 8h 1,2W; Version 5: C - zentr.Vers, AC/DC Adressmodul; Version 6: E - für zentrale Versorgung AC/DC; Version 7: FM - AT.DS&BS,LFP3,2V 3h 2W RC250; Version 8: FM8 - AT.DS&BS,LFP3,2V 8h 2W RC250

# IfcBuildingElementProxy: Gehäuse (Gehäuset.2) -Hebel- BIM
In: Default Storey
Material: St12
SolidWorks Custom Properties - Gewicht: 294.03; Material: St12

# IfcBuildingElementProxy: LED Streifen BIM_515019020 LM "300" mit 18 Everlight LEDs
In: Default Storey
Material: Alu
SolidWorks Custom Properties - Version 1: SL - LED >5500K kalt weiß BLF 100%; Version 2: SN - LED >4000K neutralweiß BLF 100%

# IfcBuildingElementProxy: Safelight Folien BIM_Piktofolie EKW 25m (2)
In: Default Storey
Material: PET
SolidWorks Custom Properties - Version 1: 00 - Piktogrammfolien f. Sonderpikto; Version 2: 20 - Piktoset LMU/R/L/Blind DIN7010; Version 3: 24 - Piktoset LM-OR/UL-UR/UL (7010); Version 4: 29 - Auslegerpiktos LMU/U/R/L(7010)

# IfcElementAssembly: ER-6 (EKW 25m)
In: Default Storey
PSet_Mass_Property - Mass Measure: 909.369; Area Measure: 351343 m2; Volume Measure: 417906 m3
